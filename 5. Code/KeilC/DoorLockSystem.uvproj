# Keil uVision project DoorLockSystem.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DoorLockSystem +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c lcd.c lcd.h uart.c uart.h servo.h keypad.c keypad.h port.h ir.h i2c.c i2c.h
